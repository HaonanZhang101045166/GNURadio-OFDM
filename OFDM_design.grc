options:
  parameters:
    author: zhn
    generate_options: qt_gui
    id: High_level_OFDM
    output_language: python
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters: {}
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters: {}
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: OFDM_Sig
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: AFter_OFDM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Source
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: OFDM_Sig
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_1, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_0, '0', digital_constellation_encoder_bc_0, '0']
- [virtual_source_1, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
